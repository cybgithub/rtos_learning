# Keil uVision project FreeRTOS_TaskScheduler.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOS_TaskScheduler
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/: main.c
  group freertos/source
    ../freertos/include/: portmacro.h FreeRTOSConfig.h task.h FreeRTOS.h portable.h projdefs.h list.h
    ../freertos/: list.c task.c
  group freertos/port
    ../freertos/: port.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
